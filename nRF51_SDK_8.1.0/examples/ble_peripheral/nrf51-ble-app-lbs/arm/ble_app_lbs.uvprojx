# Keil uVision project ble_app_lbs.uvprojx, settings and files
target nrf51822_xxaa_s110 (256K) (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.5
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ble_app_lbs +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_PCA10028 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\config;..\..\..\..\components\toolchain;..\..\..\..\components\libraries\button;..\..\..\..\components\libraries\scheduler;..\..\..\..\components\softdevice\s110\headers;..\..\..\..\components\ble\common;..\..\..\bsp;..\..\..\..\components\libraries\util;..\..\..\..\components\libraries\timer;..\..\..\..\components\libraries\gpiote;..\..\..\..\components\drivers_nrf\hal;..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\components\ble\ble_debug_assert_handler;..\..\..\..\components\ble\ble_error_log;..\..\..\..\components\drivers_nrf\pstorage;..\;..\..\..\..\components\drivers_nrf\ble_flash;..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\components\drivers_nrf\config;..\..\..\..\components\drivers_nrf\common
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ../../../../components/toolchain/: system_nrf51.c
    ../../../../components/toolchain/arm/: arm_startup_nrf51.s
  group Source Code
    ./../: main.c
  group Services
    ../: ble_lbs.c
    ../../../../components/ble/common/: ble_srv_common.c
  group Libraries
    ../../../../components/ble/ble_error_log/: ble_error_log.c
    ../../../../components/ble/ble_debug_assert_handler/: ble_debug_assert_handler.c
    ../../../../components/ble/common/: ble_conn_params.c ble_advdata.c
    ../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
    ../../../../components/libraries/button/: app_button.c
    ../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../components/libraries/crc16/: crc16.c
    ../../../../components/drivers_nrf/pstorage/: pstorage.c
    ../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../components/drivers_nrf/common/: nrf_drv_common.c
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_lbs +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD BOARD_PCA10001
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\sd_common
  memory RVCT4: ROM 0x14000 size 0xb000
  memory RVCT9: RAM 0x20002000 size 0x2000
software components: CMSIS:CORE 4.2.0
