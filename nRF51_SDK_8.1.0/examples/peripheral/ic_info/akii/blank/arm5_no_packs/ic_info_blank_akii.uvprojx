# Keil uVision project ic_info_blank_akii.uvprojx, settings and files
target nrf51822_xxac (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.5
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51822_xxac +hex
  c flags: Optim=1 OneElfS=1
  c define: BSP_DEFINES_ONLY BOARD_AKII NRF51
  c misc: --c99
  c include: ..\..\..;..\..\..\..\..\bsp;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\libraries\ic_info;..\..\..\..\..\..\components\libraries\uart;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\libraries\ic_info;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\fifo
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../../: main.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
  group nRF_Libraries
    ../../../../../../components/libraries/ic_info/: nrf51_ic_info.c
    ../../../../../../components/libraries/uart/: retarget.c
    ../../../../../../components/drivers_nrf/uart/: app_uart.c app_uart_fifo.c
software components: CMSIS:CORE 4.2.0, Device:Startup 8.0.5
