<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pca10028\s130\iar\experimental_ble_app_lns_s130_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\s110\iar\experimental_ble_app_lns_s110_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\ser_s110_spi\iar\experimental_ble_app_lns_s110_spi_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\ser_s130_hci\iar\experimental_ble_app_lns_s130_hci_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\ser_s110_hci\iar\experimental_ble_app_lns_s110_hci_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\ser_s130_spi\iar\experimental_ble_app_lns_s130_spi_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\ser_s110_uart\iar\experimental_ble_app_lns_s110_uart_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10028\ser_s130_uart\iar\experimental_ble_app_lns_s130_uart_pca10028.ewp</path>
  </project>
  <batchBuild/>
</workspace>