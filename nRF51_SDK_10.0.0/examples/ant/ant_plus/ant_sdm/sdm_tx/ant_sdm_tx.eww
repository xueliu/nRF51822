<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\auto\pca10028\iar\ant_sdm_tx_auto_s210_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\button\pca10028\iar\ant_sdm_tx_button_s210_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\auto\n5_starterkit\iar\ant_sdm_tx_auto_s210_n5_starterkit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\button\n5_starterkit\iar\ant_sdm_tx_button_s210_n5_starterkit.ewp</path>
  </project>
  <batchBuild/>
</workspace>