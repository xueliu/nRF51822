<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\speed\pca10028\iar\ant_bsc_rx_speed_s210_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\cadence\pca10028\iar\ant_bsc_rx_cadence_s210_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\combined\pca10028\iar\ant_bsc_rx_combined_s210_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\speed\n5_starterkit\iar\ant_bsc_rx_speed_s210_n5_starterkit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\cadence\n5_starterkit\iar\ant_bsc_rx_cadence_s210_n5_starterkit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\combined\n5_starterkit\iar\ant_bsc_rx_combined_s210_n5_starterkit.ewp</path>
  </project>
  <batchBuild/>
</workspace>