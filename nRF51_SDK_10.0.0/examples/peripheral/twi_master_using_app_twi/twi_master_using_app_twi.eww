<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pca10028\iar\twi_master_using_app_twi_pca10028.ewp</path>
  </project>
  <batchBuild/>
</workspace>