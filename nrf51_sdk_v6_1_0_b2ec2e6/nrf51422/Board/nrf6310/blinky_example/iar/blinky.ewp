# IAR project blinky.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: nRF51822-QFAA NordicSemi nRF51822-QFAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; NRF51; BOARD_NRF6310
  ICCARM.CCIncludePath2: ..\..\..\..\Include; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: blinky_iar.hex
  ILINK.IlinkOutputFile: blinky_iar.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: blinky.icf
  group (top)
    ../../../../Source/templates/iar/: iar_startup_nrf51.s
    ../: main.c
    ../../../../Source/nrf_delay/: nrf_delay.c
    ../../../../Source/templates/: system_nrf51.c
