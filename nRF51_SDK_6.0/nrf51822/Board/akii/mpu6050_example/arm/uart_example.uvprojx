# Keil uVision project uart_example.uvprojx, settings and files
target nrf51822_xxaa (256K) (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.5
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: uart_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_AKII
  c include: ..\..\..\..\Include;..\..\..\..\..\Include\ext_sensors
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../: main.c
  group lib
    ../../../../Source/simple_uart/: simple_uart.c
  group mpu6050
    ../: mpu6050.c
  group twi
    ../: twi_hw_master.c
target nrf51822_xxab (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.5
  cpu: as above
  output: uart_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_PCA10001
  c include: ..\..\..\..\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target nrf51822_xxaa_s110 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.5
  cpu: as above
  output: uart_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_PCA10001
  c include: ..\..\..\..\Include
  memory RVCT4: ROM 0x16000 size 0x29000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxab_s110 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.5
  cpu: as above
  output: uart_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_PCA10001
  c include: ..\..\..\..\Include
  memory RVCT4: ROM 0x16000 size 0x9000
  memory RVCT9: RAM 0x20002000 size 0x2000
target nrf51822_xxaa_s120 (256K) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.5
  cpu: as above
  output: uart_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_PCA10001
  c include: ..\..\..\..\Include
  memory RVCT4: ROM 0x18000 size 0x27000
  memory RVCT9: RAM 0x20002800 size 0x1800
target nrf51822_xxab_s120 (128K) (ARM-ADS)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.5
  cpu: as above
  output: uart_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_PCA10001
  c include: ..\..\..\..\Include
  memory RVCT4: ROM 0x18000 size 0x7000
  memory RVCT9: RAM 0x20002800 size 0x1800
target nrf51822_xxac_ak_ii (5060020::V5.06 (build 20)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.5
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: uart_example_arm +hex
  c flags: Optim=1 uC99=1
  c define: NRF51 BOARD_AKII
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 4.2.0, Device:Startup 8.0.5
