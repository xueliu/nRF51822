# Keil uVision project iot_dtls_coap_client_pca10028.uvproj, settings and files
target nrf51422_xxac_s1xx_iot (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s1xx_iot +hex
  c flags: Optim=4 OneElfS=1 wLevel=1
  c define: __HEAP_SIZE=512 __STACK_SIZE=3072 BOARD_PCA10028 BLE_STACK_SUPPORT_REQD S110 BSP_DEFINES_ONLY SWI_DISABLE0 WITH_NORDIC_IP WITH_SHA256 DTLS_PSK DTLS_ECC NDEBUG HAVE_PRNG RANDOM_NUMBER_GENERATOR=random_vector_generate NRF51 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\..\..\config;..\..\..;..\..\..\..\..\..\..\external\tinydtls-0.8.1;..\..\..\..\..\..\bsp;..\..\..\..\..\..\..\components\softdevice\s1xx_iot\headers;..\..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\components\iot\ipv6_stack\include;..\..\..\..\..\..\..\components\iot\ble_6lowpan;..\..\..\..\..\..\..\components\iot\coap;..\..\..\..\..\..\..\components\iot\include;..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\..\components\iot\iot_timer;..\..\..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..;..\..\..\..\..\..\..\components\device;..\..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\..\components\iot\ipv6_stack\pbuffer;..\..\..\..\..\..\..\components\iot\context_manager;..\..\..\..\..\..\..\components\iot\ipv6_stack\utils;..\..\..\..\..\..\..\components\iot\ipv6_stack\udp;..\..\..\..\..\..\..\components\iot\ipv6_stack\icmp6;..\..\..\..\..\..\..\components\iot\ble_ipsp;..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\..\components\libraries\trace
  asm define: __HEAP_SIZE=512 __STACK_SIZE=3072 BOARD_PCA10028 BLE_STACK_SUPPORT_REQD S110 BSP_DEFINES_ONLY SWI_DISABLE0 NRF51 SOFTDEVICE_PRESENT
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../../: main.c
  group Device
    ../../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt Abstract.txt license.txt license.txt
  group TinyDTLS
    ../../../../../../../external/tinydtls-0.8.1/: ccm.c crypto.c debug.c dtls.c dtls_time.c hmac.c list.c netq.c peer.c session.c
    ../../../../../../../external/tinydtls-0.8.1/ecc/: ecc.c
    ../../../../../../../external/tinydtls-0.8.1/aes/: rijndael.c
    ../../../../../../../external/tinydtls-0.8.1/sha2/: sha2.c
  group nRF_BLE
    ../../../../../../../components/ble/common/: ble_advdata.c ble_srv_common.c
  group nRF_Drivers
    ../../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../../components/drivers_nrf/rng/: nrf_drv_rng.c
  group nRF_IoT
    ../../../../../../../components/iot/ble_6lowpan/lib/: ble_6lowpan.lib
    ../../../../../../../components/iot/coap/: coap.c coap_message.c coap_option.c coap_queue.c coap_resource.c
    ../../../../: coap_transport_dtls.c
    ../../../../../../../components/iot/ipv6_stack/icmp6/: icmp6.c
    ../../../../../../../components/iot/context_manager/: iot_context_manager.c
    ../../../../../../../components/iot/ipv6_stack/pbuffer/: iot_pbuffer.c
    ../../../../../../../components/iot/iot_timer/: iot_timer.c
    ../../../../../../../components/iot/ipv6_stack/ipv6/: ipv6.c
    ../../../../../../../components/iot/ipv6_stack/utils/: ipv6_utils.c
    ../../../../../../../components/iot/ipv6_stack/udp/: udp6.c
  group nRF_Libraries
    ../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../../components/libraries/uart/: retarget.c
  group nRF_SoftDevice
    ../../../../../../../components/softdevice/s1xx_iot/doc/: s1xx-iot-prototype2_licence_agreement.txt
    ../../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
