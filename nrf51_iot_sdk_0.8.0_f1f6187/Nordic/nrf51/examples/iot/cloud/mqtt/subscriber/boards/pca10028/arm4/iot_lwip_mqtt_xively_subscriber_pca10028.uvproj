# Keil uVision project iot_lwip_mqtt_xively_subscriber_pca10028.uvproj, settings and files
target nrf51422_xxac_s1xx_iot (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s1xx_iot +hex
  c flags: Optim=4 OneElfS=1
  c define: __HEAP_SIZE=512 MQTT_3_1_1 BOARD_PCA10028 BLE_STACK_SUPPORT_REQD S110 BSP_DEFINES_ONLY NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  c include: ..\..\..\config;..\..\..;..\..\..\..\..\..\..\bsp;..\..\..\..\..\..\..\..\components\softdevice\s1xx_iot\headers;..\..\..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\..\..\external\lwip\src\include;..\..\..\..\..\..\..\..\external\lwip\src\include\netif;..\..\..\..\..\..\..\..\external\lwip\src\port;..\..\..\..\..\..\..\..\external\lwip\src\port\arch;..\..\..\..\..\..\..\..\components\iot\ble_6lowpan;..\..\..\..\..\..\..\..\external\lwip\src\app\mqtt;..\..\..\..\..\..\..\..\components\iot\iot_timer;..\..\..\..\..\..\..\..\components\iot\include;..\..\..\..\..\..\..\..\components\device;..\..\..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\..\..\components\libraries\mem_manager;..\..\..\..\..\..\..\..\components\iot\context_manager;..\..\..\..\..\..\..\..\components\iot\ble_ipsp;..\..\..\..\..\..\..\..\components\libraries\trace
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../../: main.c
  group Device
    ../../../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt Abstract.txt license.txt license.txt
  group Third Parties
    ../../../../../../../../external/lwip/lib/: liblwip.lib
    ../../../../../../../../external/lwip/src/app/mqtt/: mqtt.c
    ../../../../../../../../external/lwip/src/port/: nrf_platform_port.c
  group nRF_BLE
    ../../../../../../../../components/ble/common/: ble_advdata.c ble_srv_common.c
  group nRF_Drivers
    ../../../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
  group nRF_IoT
    ../../../../../../../../components/iot/ble_6lowpan/lib/: ble_6lowpan.lib
    ../../../../../../../../components/iot/context_manager/: iot_context_manager.c
    ../../../../../../../../components/iot/iot_timer/: iot_timer.c
  group nRF_Libraries
    ../../../../../../../../components/libraries/button/: app_button.c
    ../../../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../../../components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../../../components/libraries/mem_manager/: mem_manager.c
    ../../../../../../../../components/libraries/uart/: retarget.c
  group nRF_SoftDevice
    ../../../../../../../../components/softdevice/s1xx_iot/doc/: s1xx-iot-prototype2_licence_agreement.txt
    ../../../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
