# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1
  c define: NRF51, USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: Libraries/CMSIS/Include;Libraries/nrf51822/Include;applications;.;drivers;../../include;../../libcpu/arm/cortex-m0;../../libcpu/arm/common;../../components/drivers/include;../../components/finsh
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --keep *.o(FSymTab)
  group Startup Code
    Libraries/nrf51822/Source/templates/: system_nrf51.c
    Libraries/nrf51822/Source/templates/arm/: arm_startup_nrf51.s
  group Applications
    applications/: application.c startup.c
  group Drivers
    drivers/: board.c uart.c
  group Kernel
    ../../../external/rt_thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group CORTEX-M0
    ../../../external/rt_thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../external/rt_thread/libcpu/arm/cortex-m0/: cpuport.c
  group DeviceDrivers
    ../../../external/rt_thread/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../../external/rt_thread/components/finsh/: cmd.c msh.c msh_cmd.c shell.c symbol.c
