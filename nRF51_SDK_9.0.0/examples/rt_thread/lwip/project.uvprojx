# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1
  c define: BSP_DEFINES_ONLY BOARD_AKII NRF51
  c misc: --c99
  c include: Libraries/CMSIS/Include;Libraries/nrf51822/Include;applications;.;drivers;..\..\..\external\rt_thread\include;..\..\..\external\rt_thread\libcpu\arm\cortex-m0;..\..\..\external\rt_thread\libcpu\arm\common;..\..\..\external\rt_thread\components\drivers\include;..\..\..\external\rt_thread\components\finsh;..\..\..\components\drivers_nrf\hal;..\..\bsp;..\..\..\external\rt_thread\include;..\..\..\external\rt_thread\components\net\lwip-1.4.1\src\include\ipv4;..\..\..\external\rt_thread\components\net\lwip-1.4.1\src\include\ipv4\lwip;..\..\..\external\rt_thread\components\net\lwip-1.4.1\src\include\ipv6;..\..\..\external\rt_thread\components\net\lwip-1.4.1\src\include\ipv6\lwip;..\..\..\external\rt_thread\components\net\lwip-1.4.1\src\include\;..\..\..\external\rt_thread\components\net\lwip-1.4.1\src\include\netif;..\..\..\external\rt_thread\components\net\lwip-1.4.1\src\arch\include;..\..\..\external\rt_thread\components\net\lwip-1.4.1\src\arch\include\arch;..\..\..\external\rt_thread\components\net\lwip-1.4.1\src\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --keep *.o(FSymTab)
  group Applications
    applications/: application.c startup.c
  group Drivers
    drivers/: board.c uart.c
  group Kernel
    ../../../external/rt_thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group CORTEX-M0
    ../../../external/rt_thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../external/rt_thread/libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../external/rt_thread/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../../external/rt_thread/components/finsh/: cmd.c msh.c msh_cmd.c shell.c symbol.c
  group lwip
    ../../../external/rt_thread/components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../external/rt_thread/components/net/lwip-1.4.1/src/arch/: sys_arch.c
    ../../../external/rt_thread/components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../external/rt_thread/components/net/lwip-1.4.1/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
    ../../../external/rt_thread/components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../external/rt_thread/components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.2.0
