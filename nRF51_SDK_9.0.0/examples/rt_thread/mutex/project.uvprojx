# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1
  c define: BSP_DEFINES_ONLY BOARD_AKII NRF51
  c misc: --c99
  c include: Libraries/CMSIS/Include;Libraries/nrf51822/Include;applications;.;drivers;..\..\..\external\rt_thread\include;..\..\..\external\rt_thread\libcpu\arm\cortex-m0;..\..\..\external\rt_thread\libcpu\arm\common;..\..\..\external\rt_thread\components\drivers\include;..\..\..\external\rt_thread\components\finsh;..\..\..\components\drivers_nrf\hal;..\..\bsp;..\..\..\external\rt_thread\examples\kernel;..\..\..\external\rt_thread\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --keep *.o(FSymTab)
  group Applications
    applications/: application.c startup.c
  group Drivers
    drivers/: board.c uart.c
  group Kernel
    ../../../external/rt_thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group CORTEX-M0
    ../../../external/rt_thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../external/rt_thread/libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../external/rt_thread/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../../external/rt_thread/components/finsh/: cmd.c msh.c msh_cmd.c shell.c symbol.c
  group Example
    ../../../external/rt_thread/examples/kernel/: tc_comm.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.2.0
