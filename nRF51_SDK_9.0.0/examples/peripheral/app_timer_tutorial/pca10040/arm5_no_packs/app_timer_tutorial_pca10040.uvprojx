# Keil uVision project app_timer_tutorial_pca10040.uvprojx, settings and files
target nrf52832_xxaa (5060020::V5.06 (build 20)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.5
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=1 OneElfS=1
  c define: BSP_DEFINES_ONLY BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52 DEBUG
  c misc: --c99
  c include: ..\..\config\pca10040;..\..;..\..\..\..\bsp;..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\device;..\..\..\..\..\components\toolchain;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd
  asm define: BSP_DEFINES_ONLY BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: main.c
  group nRF_Drivers
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error.c nrf_assert.c
software components: CMSIS:CORE 3.40.0, Device:Startup 8.0.3
