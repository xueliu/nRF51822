# Keil uVision project mpu6050_akii.uvprojx, settings and files
target nrf51822_xxac (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.2
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51822_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: BSP_DEFINES_ONLY BOARD_PCA10028 NRF51
  c misc: --c99
  c include: ..\..\config;..\..;..\..\..\..\bsp;..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\device;..\..\..\..\..\components\toolchain;..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\components\RTT;..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\components\drivers_ext\mpu6050
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../: main.c
  group nRF_Drivers
    ../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/twi_master/: nrf_drv_twi.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c
    ../../../../../components/libraries/fifo/: app_fifo.c
  group RTT
    ../../../../../components/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../components/Syscalls/: SEGGER_RTT_Syscalls_KEIL.c
  group MPU6050
    ../../../../../components/drivers_ext/mpu6050/: mpu6050.c
software components: CMSIS:CORE 4.2.0, Device:Startup 8.0.5
