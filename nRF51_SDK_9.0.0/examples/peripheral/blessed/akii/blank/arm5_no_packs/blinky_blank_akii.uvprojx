# Keil uVision project blinky_blank_akii.uvprojx, settings and files
target nrf51822_xxac (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=1 OneElfS=1
  c define: BSP_DEFINES_ONLY BOARD_AKII NRF51
  c misc: --c99
  c include: ..\..\..;..\..\..\..\..\bsp;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\external\blessed\include;..\..\..\..\..\..\external\blessed\platform\nrf51822;..\..\..\..\..\..\external\blessed\stack;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\external\blessed;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\blessed;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\drivers_nrf\common
  asm define: BSP_DEFINES_ONLY BOARD_PCA10028 NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../../: main.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/uart/: app_uart.c
  group Blessed
    ../../../../../../external/blessed/stack/: bci.c ll.c
  group Platform
    ../../../../../../external/blessed/platform/nrf51822/: evtloop.c ll-plat.c log.c radio.c random.c timer.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.2.0
