# Keil uVision project adafruit_tag_reader_pca10028.uvprojx, settings and files
target nrf51422_xxac (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.2
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=1 OneElfS=1
  c define: DEBUG ENABLE_DEBUG_LOG_SUPPORT T2T_PARSER_ENABLE BOARD_PCA10028 NRF51 SWI_DISABLE0 NRF_LOG_USES_UART=1 NRF_LOG_USES_RTT
  c misc: --c99
  c include: ..\..\config\adafruit_tag_reader_pca10028;..\..\config;..\..\..\..\..\components\drivers_ext\segger_rtt;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\components\experimental_nfc\t2t_parser;..\..\..\..\..\components\libraries\button;..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\libraries\trace;..\..\..\..\..\components\libraries\uart;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\toolchain;..\..\..\..\bsp;..\..;..\..\..\..\..\external\nfc_adafruit_library
  asm define: DEBUG ENABLE_DEBUG_LOG_SUPPORT T2T_PARSER_ENABLE BOARD_PCA10028 NRF51 SWI_DISABLE0 NRF_LOG_USES_UART=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: main.c
  group Board Support
    ../../../../bsp/: bsp.c
  group Documentation
    ../../: Abstract.txt license.txt
  group Third Parties
    ../../../../../external/nfc_adafruit_library/: adafruit_pn532.c
  group nRF_Drivers
    ../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../../../../components/drivers_ext/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../../../components/libraries/button/: app_button.c
    ../../../../../components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c nrf_log.c
    ../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../components/libraries/timer/: app_timer.c
    ../../../../../components/libraries/trace/: app_trace.c
    ../../../../../components/libraries/uart/: retarget.c
  group nRF_NFC
    ../../../../../components/experimental_nfc/t2t_parser/: nfc_t2t_parser.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.3.1
