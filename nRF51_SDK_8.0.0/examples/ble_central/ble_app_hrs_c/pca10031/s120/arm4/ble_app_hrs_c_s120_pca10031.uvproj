# Keil uVision project ble_app_hrs_c_s120_pca10031.uvproj, settings and files
target nrf51422_xxac_s120 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s120 +hex
  c flags: Optim=4 OneElfS=1
  c define: __HEAP_SIZE=0 BLE_STACK_SUPPORT_REQD S120 BOARD_PCA10031 BSP_UART_SUPPORT NRF51 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\..\..\config;..\..\..\..\..\..\components\softdevice\s120\headers;..\..\..\..\..\bsp;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\..\components\ble\ble_services\ble_bas_c;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\ble\ble_db_discovery;..\..\..\..\..\..\components\ble\device_manager;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\components\drivers_nrf\pstorage
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1d000 size 0x23000
  memory RVCT9: RAM 0x20002800 size 0x5800
  group Application
    ../../../: main.c
  group Board Support
    ../../../../../bsp/: bsp.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group nRF_BLE
    ../../../../../../components/ble/ble_services/ble_bas_c/: ble_bas_c.c
    ../../../../../../components/ble/ble_db_discovery/: ble_db_discovery.c
    ../../../../../../components/ble/ble_services/ble_hrs_c/: ble_hrs_c.c
    ../../../../../../components/ble/common/: ble_srv_common.c
    ../../../../../../components/ble/device_manager/: device_manager_central.c
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/trace/: app_trace.c
    ../../../../../../components/libraries/uart/: retarget.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s120/doc/: s120_nrf51822_2.0.0_licence_agreement.txt
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
