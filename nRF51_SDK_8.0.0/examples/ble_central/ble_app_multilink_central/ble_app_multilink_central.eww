<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pca10028\s120\iar\ble_app_multilink_central_s120_pca10028.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pca10031\s120\iar\ble_app_multilink_central_s120_pca10031.ewp</path>
  </project>
  <batchBuild/>
</workspace>