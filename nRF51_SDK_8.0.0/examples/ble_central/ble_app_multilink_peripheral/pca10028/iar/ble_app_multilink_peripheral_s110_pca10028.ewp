# IAR project ble_app_multilink_peripheral_s110_pca10028.ewp, settings and files
configuration nrf51422_xxac_s110 (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BLE_STACK_SUPPORT_REQD; BOARD_PCA10028; S110; NRF51; SOFTDEVICE_PRESENT
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\bsp; ..\..\..\..\..\components\softdevice\s110\headers; ..\..\..\..\..\components\ble\common; ..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\components\libraries\button; ..\..\..\..\..\components\device; ..\..\..\..\..\components\toolchain; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\components\ble\device_manager; ..\..\..\..\..\components\softdevice\common\softdevice_handler; ..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\libraries\gpiote; ..\..\..\..\..\components\drivers_nrf\pstorage; ..\..\..\..\..\components\libraries\trace; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: ble_app_multilink_peripheral_s110_pca10028.hex
  ILINK.IlinkOutputFile: ble_app_multilink_peripheral_s110_pca10028.out
  ILINK.IlinkIcfFile: ble_app_multilink_peripheral_iar_nrf51.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../components/libraries/button/: app_button.c
    ../../../../../components/libraries/util/: app_error.c nrf_assert.c
    ../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../components/libraries/timer/: app_timer.c
    ../../../../../components/libraries/trace/: app_trace.c
    ../../../../../components/libraries/uart/: retarget.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group Board Support
    ../../../../bsp/: bsp.c
  group Application
    ../../: main.c
  group nRF_BLE
    ../../../../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../../../components/ble/device_manager/: device_manager_peripheral.c
  group Device
    ../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../components/toolchain/: system_nrf51.c
  group nRF_SoftDevice
    ../../../../../components/softdevice/s110/doc/: s110_nrf51_8.0.0_licence-agreement.txt
    ../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
