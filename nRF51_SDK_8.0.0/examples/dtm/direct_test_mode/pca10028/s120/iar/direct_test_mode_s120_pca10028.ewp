# IAR project direct_test_mode_s120_pca10028.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BSP_DEFINES_ONLY; BOARD_PCA10028; S120; NRF51; SOFTDEVICE_PRESENT
  ICCARM.CCIncludePath2: ..\..\..; ..\..\..\..\..\bsp; ..\..\..\..\..\..\components\softdevice\s120\headers; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\ble\ble_dtm; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\toolchain; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: direct_test_mode_s120_pca10028.hex
  ILINK.IlinkOutputFile: direct_test_mode_s120_pca10028.out
  ILINK.IlinkIcfFile: direct_test_mode_iar_nrf51.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Application
    ../../../: main.c
  group nRF_BLE
    ../../../../../../components/ble/ble_dtm/: ble_dtm.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s120/doc/: s120_nrf51822_2.0.0_licence_agreement.txt
  group Documentation
    ../../../: Abstract.txt license.txt
