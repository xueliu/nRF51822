# Keil uVision project simple_timer_pca10028.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: BOARD_PCA10028 NRF51
  c misc: --c99
  c include: ..\..\config;..\..;..\..\..\..\bsp;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\libraries\simple_timer;..\..\..\..\..\components\device;..\..\..\..\..\components\toolchain;..\..\..\..\..\components\libraries\button;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd
  asm define: BOARD_PCA10028 NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: main.c
  group Board Support
    ../../../../bsp/: bsp.c
  group Device
    ../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_soc.c
  group nRF_Libraries
    ../../../../../components/libraries/button/: app_button.c
    ../../../../../components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c
    ../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../components/libraries/simple_timer/: app_simple_timer.c
    ../../../../../components/libraries/timer/: app_timer.c
