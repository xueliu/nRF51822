# IAR project spi_slave_pca10028.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD_PCA10028; NRF51
  ICCARM.CCIncludePath2: ..\..; ..\..\..\..\bsp; ..\..\..\..\..\components\drivers_nrf\spi_slave; ..\..\..\..\..\components\device; ..\..\..\..\..\components\toolchain; ..\..\..\..\..\components\libraries\button; ..\..\..\..\..\components\libraries\util; ..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\components\libraries\gpiote; ..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD_PCA10028; NRF51
  OBJCOPY.OOCOutputFile: spi_slave_pca10028.hex
  ILINK.IlinkOutputFile: spi_slave_pca10028.out
  ILINK.IlinkIcfFile: spi_slave_iar_nrf51.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../components/libraries/button/: app_button.c
    ../../../../../components/libraries/util/: app_error.c app_util_platform.c
    ../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../components/libraries/timer/: app_timer.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../components/drivers_nrf/spi_slave/: spi_slave.c
  group Board Support
    ../../../../bsp/: bsp.c
  group Application
    ../../: main.c spi_slave_example.c
  group Device
    ../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../components/toolchain/: system_nrf51.c
