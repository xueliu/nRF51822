# Keil uVision project spi_master_pca10028.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: SPI_MASTER_0_ENABLE  SPI_MASTER_1_ENABLE  BOARD_PCA10028 NRF51
  c misc: --c99
  c include: ..\..;..\..\..\..\bsp;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\components\device;..\..\..\..\..\components\toolchain;..\..\..\..\..\components\libraries\button;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: main.c
  group Board Support
    ../../../../bsp/: bsp.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../components/drivers_nrf/hal/: nrf_delay.c
    ../../../../../components/drivers_nrf/nrf_soc_nosd/: nrf_soc.c
    ../../../../../components/drivers_nrf/spi_master/: spi_master.c
  group nRF_Libraries
    ../../../../../components/libraries/button/: app_button.c
    ../../../../../components/libraries/util/: app_error.c app_util_platform.c
    ../../../../../components/libraries/gpiote/: app_gpiote_fast_detect.c
    ../../../../../components/libraries/timer/: app_timer.c
software components: CMSIS:CORE 3.40.0, Device:Startup 7.1.0
