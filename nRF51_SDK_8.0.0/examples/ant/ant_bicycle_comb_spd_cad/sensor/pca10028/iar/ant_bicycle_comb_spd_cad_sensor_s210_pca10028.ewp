# IAR project ant_bicycle_comb_spd_cad_sensor_s210_pca10028.ewp, settings and files
configuration nrf51422_xxac (ARM)
  General.OGChipSelectEditMenu: nrf51422_xxac nRF51422_xxAC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ANT_STACK_SUPPORT_REQD; TRACE_UART; S210; BOARD_PCA10028; NRF51; SOFTDEVICE_PRESENT
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\..\..\..\components\softdevice\s210\headers; ..\..\..\..\..\bsp; ..\..\..\..\..\..\components\libraries\timer; ..\..\..\..\..\..\components\drivers_nrf\uart; ..\..\..\..\..\..\components\device; ..\..\..\..\..\..\components\toolchain; ..\..\..\..\..\..\components\libraries\button; ..\..\..\..\..\..\components\libraries\util; ..\..\..\..\..\..\components\drivers_nrf\hal; ..\..\..\..\..\..\components\libraries\fifo; ..\..\..\..\..\..\components\libraries\gpiote; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: ant_bicycle_comb_spd_cad_sensor_s210_pca10028.hex
  ILINK.IlinkOutputFile: ant_bicycle_comb_spd_cad_sensor_s210_pca10028.out
  ILINK.IlinkIcfFile: ant_bicycle_comb_spd_cad_sensor_iar_nrf51.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group nRF_Libraries
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../../components/libraries/timer/: app_timer.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
  group Board Support
    ../../../../../bsp/: bsp.c
  group Application
    ../../: cbsc_tx.c main.c main_cbsc_tx.c retarget.c
  group Device
    ../../../../../../components/toolchain/iar/: iar_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s210/doc/: s210_nrf51422_4.0.1_licence_agreement.txt
