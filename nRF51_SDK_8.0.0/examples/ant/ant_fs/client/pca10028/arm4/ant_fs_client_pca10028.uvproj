# Keil uVision project ant_fs_client_pca10028.uvproj, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac +hex
  c flags: Optim=4 OneElfS=1
  c define: ANT_STACK_SUPPORT_REQD TRACE_MEM_WRITE_OFF S210 BOARD_PCA10028 NRF51 SOFTDEVICE_PRESENT
  c misc: --c99
  c include: ..\..\include;..\..\..\..\..\..\components\softdevice\s210\headers;..\..\..\..\..\bsp;..\..\..\..\..\..\components\libraries\ant_fs;..\..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\libraries\gpiote
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0xd000 size 0x33000
  memory RVCT9: RAM 0x20000900 size 0x7700
  group Application
    ../../: main.c mem.c retarget.c
  group Board Support
    ../../../../../bsp/: bsp.c
  group Device
    ../../../../../../components/toolchain/arm/: arm_startup_nrf51.s
    ../../../../../../components/toolchain/: system_nrf51.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/uart/: app_uart_fifo.c
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c
  group nRF_Libraries
    ../../../../../../components/libraries/ant_fs/: antfs.c crc.c
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/util/: app_error.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../../components/libraries/gpiote/: app_gpiote.c
    ../../../../../../components/libraries/timer/: app_timer.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s210/doc/: s210_nrf51422_4.0.1_licence_agreement.txt
