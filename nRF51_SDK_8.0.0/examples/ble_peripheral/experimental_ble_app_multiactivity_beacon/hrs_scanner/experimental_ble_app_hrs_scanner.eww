<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\pca10028\iar\experimental_ble_app_hrs_scanner_s110_pca10028.ewp</path>
  </project>
  <batchBuild/>
</workspace>